Commit message: update laser frame origin to new lidar position

File: description/armatron_description.urdf (robot description, URDF)
Before this commit: robot armatron, 3 links, 2 joints
Joints:
- joint laser_joint: origin xyz=0.0 0.0 0.0 rpy=0 0 3.141 -> xyz=0.125 0.0 0.0 rpy=0 0 3.141
